# Keil uVision project Ping-Pong-L0.uvprojx, settings and files
target Ping-Pong-L0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073RZHx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Ping-Pong-L0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_DEBUGGER USE_MODEM_LORA
  c include: ..\..\..\src;..\..\..\src\boards\AcsipNode;..\..\..\src\boards\AcsipNode\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto;..\..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group apps
    ../../../src/apps/ping-pong/AcsipNode/: main.c
  group boards\AcsipNode
    ../../../src/boards/AcsipNode/: adc-board.c board.c gpio-board.c hw-timer-board.c i2c-board.c rtc-board.c spi-board.c sx1276-board.c uart-board.c
  group boards\AcsipNode\cmsis
    ../../../src/boards/AcsipNode/cmsis/: system_stm32l0xx.c
    ../../../src/boards/AcsipNode/cmsis/arm-std/: startup_stm32l073xx.s
  group STM32L0xx_HAL_Driver
    ../../../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group radio
    ../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../src/system/: adc.c delay.c fifo.c gpio.c i2c.c timer.c uart.c
software components: CMSIS:CORE 4.1.0
